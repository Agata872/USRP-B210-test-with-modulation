options:
  parameters:
    author: Dramco_Tianzheng
    generate_options: qt_gui
    id: Server
    output_language: python
    title: Server_process
  states: {}

blocks:
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr
      from collections import deque

      # ====== 关键：让 GRC 生成端口 ======
      in_sig = None
      out_sig = None
      in_msg = ['raw', 'dec']   # 生成两个 message 输入端口：raw / dec
      out_msg = []              # 不需要输出端口（你只做比较打印）
      # ===================================

      class blk(gr.sync_block):
          def __init__(self, print_every=50, max_pending=200):
              gr.sync_block.__init__(
                  self,
                  name="Message Comparator (PDU bits)",
                  in_sig=None,
                  out_sig=None
              )

              self.print_every = int(print_every)
              self.max_pending = int(max_pending)

              # message ports（端口名必须和 in_msg 里一致）
              self.message_port_register_in(pmt.intern("raw"))
              self.message_port_register_in(pmt.intern("dec"))
              self.set_msg_handler(pmt.intern("raw"), self._handle_raw)
              self.set_msg_handler(pmt.intern("dec"), self._handle_dec)

              self.raw_map = {}
              self.dec_map = {}
              self.raw_fifo = deque()
              self.dec_fifo = deque()

              self.frames = 0
              self.total_bits = 0
              self.total_errs = 0
              self.len_mismatch = 0

          def _pdu_to_u8(self, msg):
              if not pmt.is_pair(msg):
                  return None, None
              meta = pmt.car(msg)
              data = pmt.cdr(msg)
              try:
                  vec = pmt.u8vector_elements(data)
              except Exception:
                  return None, None

              meta_dict = {}
              if pmt.is_dict(meta):
                  try:
                      meta_dict = pmt.to_python(meta)
                  except Exception:
                      meta_dict = {}
              return meta_dict, np.frombuffer(bytes(vec), dtype=np.uint8)

          def _get_seq(self, meta_dict):
              for k in ("seq", "frame_id", "pkt_id", "id"):
                  if k in meta_dict:
                      try:
                          return int(meta_dict[k])
                      except Exception:
                          return None
              return None

          def _compare_and_update(self, raw_bits, dec_bits, seq=None):
              n1, n2 = int(raw_bits.size), int(dec_bits.size)
              if n1 != n2:
                  self.len_mismatch += 1
                  n = min(n1, n2)
                  raw_bits = raw_bits[:n]
                  dec_bits = dec_bits[:n]
              else:
                  n = n1

              errs = int(np.count_nonzero(raw_bits != dec_bits))

              self.frames += 1
              self.total_bits += n
              self.total_errs += errs

              if self.frames % self.print_every == 0:
                  ber = (self.total_errs / self.total_bits) if self.total_bits > 0 else 0.0
                  tag = f"SEQ={seq} " if seq is not None else ""
                  print(f"[Comparator] {tag}frames={self.frames}, bits={self.total_bits}, "
                        f"errs={self.total_errs}, BER={ber:.6e}, len_mismatch={self.len_mismatch}")

          def _trim_pending(self):
              while len(self.raw_map) > self.max_pending:
                  self.raw_map.pop(next(iter(self.raw_map)))
              while len(self.dec_map) > self.max_pending:
                  self.dec_map.pop(next(iter(self.dec_map)))
              while len(self.raw_fifo) > self.max_pending:
                  self.raw_fifo.popleft()
              while len(self.dec_fifo) > self.max_pending:
                  self.dec_fifo.popleft()

          def _handle_raw(self, msg):
              meta, raw = self._pdu_to_u8(msg)
              if raw is None:
                  return
              seq = self._get_seq(meta)
              if seq is not None:
                  self.raw_map[seq] = raw
                  if seq in self.dec_map:
                      dec = self.dec_map.pop(seq)
                      raw2 = self.raw_map.pop(seq)
                      self._compare_and_update(raw2, dec, seq=seq)
                  self._trim_pending()
              else:
                  self.raw_fifo.append(raw)
                  if len(self.dec_fifo) > 0:
                      dec = self.dec_fifo.popleft()
                      raw2 = self.raw_fifo.popleft()
                      self._compare_and_update(raw2, dec)
                  self._trim_pending()

          def _handle_dec(self, msg):
              meta, dec = self._pdu_to_u8(msg)
              if dec is None:
                  return
              seq = self._get_seq(meta)
              if seq is not None:
                  self.dec_map[seq] = dec
                  if seq in self.raw_map:
                      raw = self.raw_map.pop(seq)
                      dec2 = self.dec_map.pop(seq)
                      self._compare_and_update(raw, dec2, seq=seq)
                  self._trim_pending()
              else:
                  self.dec_fifo.append(dec)
                  if len(self.raw_fifo) > 0:
                      raw = self.raw_fifo.popleft()
                      dec2 = self.dec_fifo.popleft()
                      self._compare_and_update(raw, dec2)
                  self._trim_pending()
    max_pending: '200'
    print_every: '50'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:5555
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:5556
    timeout: '100'
  states: {}

connections:
- [zeromq_pull_msg_source_0, out, epy_block_0, raw]
- [zeromq_pull_msg_source_0_0, out, epy_block_0, dec]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
